# Keil uVision project indago-smart-board-v4.uvprojx, settings and files
target indago-smart-board-v4 (6150000::V6.15::ARMCLANG)
  device: STM32L422RBTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: indago-smart-board-v4 +hex
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c
  group Src
    ../Src/: list.c main.c print.c queue.c stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c ublox_gps.c ublox_r4.c
  group Inc
    ../Inc/: aws.h list.h main.h print.h queue.h stm32l4xx_hal_conf.h stm32l4xx_it.h ublox_gps.h ublox_r4.h
  group MDK-ARM
    ./: startup_stm32l422xx.s
  group Drivers/Jansson
    ../Drivers/Jansson/: jansson.h jansson_config.h
software components: CMSIS:CORE 5.4.0
