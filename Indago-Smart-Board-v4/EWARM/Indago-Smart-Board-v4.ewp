# IAR project Indago-Smart-Board-v4.ewp, settings and files
configuration Indago-Smart-Board-v4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L422RB ST STM32L422RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L422xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\paho.mqtt.embedded-c\MQTTClient-C\src; ..\Drivers\paho.mqtt.embedded-c\MQTTPacket\src
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Indago-Smart-Board-v4.hex
  ILINK.IlinkOutputFile: Indago-Smart-Board-v4.out
  ILINK.IlinkIcfFile: stm32l422xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l422xx.s
  group Application/Inc
    ../Inc/: aws.h list.h main.h print.h queue.h stm32l4xx_hal_conf.h stm32l4xx_it.h ublox_gps.h ublox_r4.h
  group Application/Src
    ../Src/: list.c main.c print.c queue.c stm32l4xx_hal_msp.c stm32l4xx_it.c ublox_gps.c ublox_r4.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/Paho MQTT
    ../Drivers/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c MQTTClient.h
    ../Drivers/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
